# Keil uVision project lab6.uvproj, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: LPC1114/102 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lab6
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: startup_LPC11xx.s LPC11xx.inc BusyWait.s ChannelLoc.s DisplayChan.s DisplayMemLoc.s DisplayRecall.s DisplayT0.s DisplayT1.s init.s Keypad_init.s LCD_command.s LCD_data.s LCD_init.s LCD_init1.s main.s MemRec.s Name.s PIOINT0_IRQHandler.s print_string.s T0_value.s T1_value.s TIMER32_0_IRQHandler.s Chan_LED_on.s division.s MemLoc.s MR0_input.s MR1_input.s Mem_0_Loc.s Mem_1_Loc.s Mem_2_Loc.s Mem_3_Loc.s Mem_4_Loc.s Mem_5_Loc.s Mem_6_Loc.s Mem_7_Loc.s Mem_8_Loc.s Mem_9_Loc.s Mem_0_Rec.s Mem_1_Rec.s Mem_2_Rec.s Mem_3_Rec.s Mem_4_Rec.s Mem_5_Rec.s Mem_6_Rec.s Mem_7_Rec.s Mem_8_Rec.s Mem_9_Rec.s
