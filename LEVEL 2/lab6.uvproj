# Keil uVision project lab6.uvproj, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: LPC1114/102 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lab6
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: startup_LPC11xx.s LPC11xx.inc BusyWait.s ChannelLoc.s DisplayChan.s DisplayMemLoc.s DisplayRecall.s DisplayT0.s DisplayT1.s init.s Keypad_init.s LCD_command.s LCD_data.s LCD_init.s LCD_init1.s main.s MemLoc.s MemRec.s Name.s PIOINT0_IRQHandler.s print_string.s T0_value.s T1_value.s TIMER32_0_IRQHandler.s Chan_LED_on.s TIMER32_1_IRQHandler.s
